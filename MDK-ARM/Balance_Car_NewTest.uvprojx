# Keil uVision project Balance_Car_NewTest.uvprojx, settings and files
target Balance_Car_NewTest (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Balance_Car_NewTest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../CRSF;../Users;../MDK-ARM;../MOTOR;../Control;..\MPU&DMP;..\MPU&DMP\MPU_INT;..\MPU&DMP\MPU6050;..\MPU&DMP\MPU6050\eMPL;..\pid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group CRSF
    ../CRSF/: crsf_parse.c crsf_parse.h
  group User
    ../Users/: printf.c sys.c delay.c
  group DMP
    ../MPU&DMP/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group MPU6050
    ../MPU&DMP/MPU6050/: mpuiic.c mpu6050.c mpuiic.h mpu6050.h
  group Motor
    ../MOTOR/: motor.c motor.h
  group Control
    ../Control/: control.c control.h
    ./: backup.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group pid
    ../pid/: balance.c balance.h
software components: CMSIS:CORE 4.3.0
